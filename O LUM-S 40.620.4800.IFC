Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Assy_Screen_620_LED_L_EM_Completed.IFC
Time: 2023-07-27T08:15:31
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: Assy_Screen_620_LED_L_EM_Completed
In: Default Storey
SolidWorks Custom Properties - Description: PWR(40W);LUM.FLUX(4800lm);TEMP(4000K); IP65
