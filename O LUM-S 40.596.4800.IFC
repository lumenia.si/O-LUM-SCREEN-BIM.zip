Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Assy_Screen_596_LED_EM_Completed_simplified.IFC
Time: 2023-07-27T08:06:21
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Assy_Screen_596_LED_EM_Completed_simplified
In: Default Storey
SolidWorks Custom Properties - Description: PWR(40W);LUM.FLUX(4800lm);TEMP(4000K); IP65
